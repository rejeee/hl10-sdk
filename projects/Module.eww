<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HL10\IAR\HL10.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\HL10-Lite\IAR\HL10-Lite.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\HL9\IAR\HL9.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\HL9-Lite\IAR\HL9-Lite.ewp</path>
  </project>
  <batchBuild/>
</workspace>


